# Keil uVision project flow.uvprojx, settings and files
target Relaese (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: flow
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\include\cmsis\;..\include\stm32f10x_driver\;..\include\flow\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group cmsis
    ../cmsis/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group stm32f10x_driver
    ../stm32f10x_driver/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group flow
    ./: main.c stm32f10x_it.c usart.c core.c simcard.c flowmeter.c watchdog.c util.c
